<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CSE316_LAB1.ewp</path>
    </project>
    <batchBuild />
</workspace>
